# Keil uVision project Lab5.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Lab3 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0xe800
  memory RVCT10: RAM 0x7fe00000 size 0x3800
  group Source Group 1
    ./Source/: LPC2300.s
  group SROS
    ./Source/: ISR.c mailboxObjectAsm.s mutexObjectAsm.s rtos.c rtos.h rtosAsm.h rtosAsm.s semaphoreObjectAsm.s typeDef.h main.c
  group Timer
    ./Source/Timer/: timer.c timer.h
  group Serial
    ./Source/Serial/: Retarget.c Serial.C Serial.h
  group LED
    ./Source/LED/: led.c led.h
  group LCD
    ./Source/LCD/: LCD.h LCD_4bit.c
  group flag
    ./Source/Flag/: flag.c flag.h
